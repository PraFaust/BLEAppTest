# IAR project bluetooth_health_thermometer_demo_RFS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW40Z160xxx4 Freescale MKW40Z160xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; IAR; CPU_MKW40Z160VHT4
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.PreInclude: examples/bluetooth/health_thermometer_demo/frdmkw40z/bare_metal/app_preinclude.h
  ICCARM.CCIncludePath2: $_KSDK13_FWK524_PATH_$/platform/CMSIS/Include; boards/frdmkw40z; $_KSDK13_FWK524_PATH_$/platform/devices; $_KSDK13_FWK524_PATH_$/platform/devices/MKW40Z4/include; $_KSDK13_FWK524_PATH_$/platform/devices/MKW40Z4/startup; $_KSDK13_FWK524_PATH_$/platform/system/src/clock/MKW40Z4; $_KSDK13_FWK524_PATH_$/platform/devices; $_KSDK13_FWK524_PATH_$/platform/devices/MKW40Z4/startup; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/Flash/Internal; $_KSDK13_FWK524_PATH_$/platform/drivers/src/flash/C90TFS/drvsrc/include; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/GPIOIrq; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/Keyboard/Interface; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/LED/Interface; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/Common; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/MemManager/Interface; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/Messaging/Interface; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/OSAbstraction/Interface; $_KSDK13_FWK524_PATH_$/platform/osa/inc; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/Panic/Interface; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/RNG/Interface; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/SerialManager/Interface; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/TimersManager/Interface; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/TimersManager/Source; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/FunctionLib; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/Lists; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/SecLib; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/ModuleInfo; $_KSDK13_FWK524_PATH_$/../ConnSw/bluetooth/host/interface; examples/bluetooth/common; examples/bluetooth/common; $_KSDK13_FWK524_PATH_$/../ConnSw/bluetooth/controller/interface; examples/bluetooth/common; $_KSDK13_FWK524_PATH_$/../ConnSw/bluetooth/hci_transport/interface; examples/bluetooth/common/gatt_db; examples/bluetooth/common/gatt_db/macros; $_KSDK13_FWK524_PATH_$/../ConnSw/bluetooth/profiles/battery; $_KSDK13_FWK524_PATH_$/../ConnSw/bluetooth/profiles/device_info; $_KSDK13_FWK524_PATH_$/../ConnSw/bluetooth/profiles/health_thermometer; $_KSDK13_FWK524_PATH_$/../ConnSw/bluetooth/profiles/current_time; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/XCVR/MKW40Z4; examples/bluetooth/health_thermometer_demo/common; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/DCDC/Interface; $_KSDK13_FWK524_PATH_$/platform/drivers/inc; $_KSDK13_FWK524_PATH_$/platform/system/inc; $_KSDK13_FWK524_PATH_$/platform/hal/inc; $_KSDK13_FWK524_PATH_$/platform/utilities/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: generic.bin
  ILINK.IlinkOutputFile: health_thermometer_demo_BM.out
  ILINK.IlinkConfigDefines: gUseNVMLink_d=1; __ram_vector_table__=1
  ILINK.IlinkIcfFile: platform/devices/MKW40Z4/linker/iar/MKW40Z160xxx4_connectivity.icf
  ILINK.IlinkAdditionalLibs: $_KSDK13_FWK524_PATH_$/../ConnSw/bluetooth/host/lib/ble_host_peripheral_lib.a; $_KSDK13_FWK524_PATH_$\lib\ksdk_platform_lib\iar\KW40Z4\debug\libksdk_platform.a; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/SecLib/lib_crypto_IAR_M0.a; $_KSDK13_FWK524_PATH_$/../ConnSw/bluetooth/controller/lib/ble_controller_lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; IAR; CPU_MKW40Z160VHT4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkAdditionalLibs: $_KSDK13_FWK524_PATH_$/../ConnSw/bluetooth/host/lib/ble_host_peripheral_lib.a; $_KSDK13_FWK524_PATH_$\lib\ksdk_platform_lib\iar\KW40Z4\release\libksdk_platform.a; $_KSDK13_FWK524_PATH_$/../ConnSw/framework/SecLib/lib_crypto_IAR_M0.a; $_KSDK13_FWK524_PATH_$/../ConnSw/bluetooth/controller/lib/ble_controller_lib.a
  group app/common
    examples/bluetooth/common/: ApplMain.c ApplMain.h ble_controller_task.c ble_controller_task_config.h ble_host_task_config.h ble_host_tasks.c ble_init.c ble_init.h
  group app/common/gatt_db
    examples/bluetooth/common/gatt_db/: gatt_database.c gatt_db_handles.h
  group app/common/gatt_db/macros
    examples/bluetooth/common/gatt_db/macros/: gatt_alloc_x.def gatt_db_macros.h gatt_db_x_macros.def gatt_decl_x.def gatt_enum_x.def gatt_init_x.def gatt_size_x.def gatt_uuid_decl_x.def gatt_uuid_def_x.def
  group app/health_thermometer_demo
    examples/bluetooth/health_thermometer_demo/common/: app.c app.h app_config.c gatt_db.h gatt_uuid128.h
    examples/bluetooth/health_thermometer_demo/frdmkw40z/bare_metal/: app_preinclude.h
  group bluetooth/controller/interface
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/bluetooth/controller/interface/: controller_interface.h
  group bluetooth/hci_transport/interface
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/bluetooth/hci_transport/interface/: hci_transport.h
  group bluetooth/hci_transport/source
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/bluetooth/hci_transport/source/: hcit_serial_interface.c
  group bluetooth/host/interface
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/bluetooth/host/interface/: att_errors.h ble_constants.h ble_general.h ble_host_tasks.h ble_sig_defines.h ble_utils.h gap_interface.h gap_types.h gatt_client_interface.h gatt_database.h gatt_db_app_interface.h gatt_interface.h gatt_server_interface.h gatt_types.h hci_interface.h hci_types.h l2ca_cb_interface.h l2ca_interface.h l2ca_types.h smp_packets.h smp_types.h vendor_debug_commands.h
  group bluetooth/host/source
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/bluetooth/host/source/: ble_globals.c
  group bluetooth/profiles/battery
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/bluetooth/profiles/battery/: battery_service.c
  group bluetooth/profiles/current_time
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/bluetooth/profiles/current_time/: current_time_service.c
  group bluetooth/profiles/device_info
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/bluetooth/profiles/device_info/: device_info_service.c
  group bluetooth/profiles/health_thermometer
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/bluetooth/profiles/health_thermometer/: health_thermometer_service.c
  group bluetooth/profiles/interface
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/bluetooth/profiles/battery/: battery_interface.h
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/bluetooth/profiles/current_time/: current_time_interface.h
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/bluetooth/profiles/device_info/: device_info_interface.h
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/bluetooth/profiles/health_thermometer/: health_thermometer_interface.h
  group framework/Common
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/Common/: EmbeddedTypes.h FwkInit.c
  group framework/DCDC/Interface
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/DCDC/Interface/: DCDC.h
  group framework/DCDC/Source
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/DCDC/Source/: DCDC.c
  group framework/Flash/Internal
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/KSDK_1.3.0/platform/drivers/src/flash/C90TFS/drvsrc/source/: CopyToRam.c DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c PFlashGetProtection.c PFlashSetProtection.c PFlashSwap.c PFlashSwapCtl.c SetEEEEnable.c
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/Flash/Internal/: Flash_Adapter.c Flash_Adapter.h
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/KSDK_1.3.0/platform/drivers/src/flash/C90TFS/drvsrc/include/: FTFx_KX_flash_config.h SSD_FTFx.h SSD_FTFx_Common.h SSD_FTFx_Internal.h SSD_Types.h
  group framework/FunctionLib
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/GPIOIrq/Interface
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/GPIOIrq/: GPIO_IrqAdapter.h
  group framework/GPIOIrq/Source
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/GPIOIrq/: GPIO_IrqAdapter.c
  group framework/Keyboard/Interface
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/LED/Interface/: LED.h
  group framework/LED/Source
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/LED/Source/: LED.c
  group framework/Lists
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/Lists/: GenericList.c GenericList.h
  group framework/MemManager/Interface
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/Messaging/Source/: Messaging.c
  group framework/ModuleInfo
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/ModuleInfo/: ModuleInfo.h
  group framework/OSAbstraction/Interface
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/OSAbstraction/Interface/: fsl_osa_ext.h fsl_osa_ext_config.h
  group framework/OSAbstraction/Source
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/OSAbstraction/Source/: fsl_osa_ext_bm.c
  group framework/Panic/Interface
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/Panic/Interface/: Panic.h
  group framework/Panic/Source
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/Panic/Source/: Panic.c
  group framework/Reset/Source
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/Reset/: Reset.c
  group framework/RNG/Interface
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/RNG/Source/: RNG.c
  group framework/SecLib
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/SecLib/: SecLib.c SecLib.h
  group framework/SerialManager/Interface
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/SerialManager/Interface/: SerialManager.h
  group framework/SerialManager/Source
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/SerialManager/Source/: SerialManager.c
  group framework/TimersManager/Interface
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.c TMR_Adapter.h
  group framework/XCVR/MKW40Z4
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/ConnSw/framework/XCVR/MKW40Z4/: BLEDefaults.h ifr_mkw40z4_radio.c ifr_mkw40z4_radio.h ifr_tbl_apache_radio.h KW4xXcvrDrv.c KW4xXcvrDrv.h overwrites.h tsm_ll_timing.c tsm_ll_timing.h tsm_timing_ble.h tsm_timing_zigbee.h ZigbeeDefaults.h
  group KSDK
    boards/frdmkw40z/: board.c board.h gpio_pins.c gpio_pins.h hardware_init.c pin_mux.c pin_mux.h
  group RTOS/Startup
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/KSDK_1.3.0/platform/devices/: startup.c startup.h
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/KSDK_1.3.0/platform/devices/MKW40Z4/startup/iar/: startup_MKW40Z4.s
    C:/Freescale/KW40Z_Connectivity_Software_1.0.1/KSDK_1.3.0/platform/devices/MKW40Z4/startup/: system_MKW40Z4.c system_MKW40Z4.h
